# Keil uVision project ZL_6_Motor_Alarm_Process.uvproj, settings and files
target Alarm (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ZL_6_Motor_Alarm_Process +hex
  c flags: Optimize=9 SizeSpeed=1
  group system
    ./: STARTUP.A51 main.c system_init.c variable.c
  group task
    ./task/alarm/: alarm_task.c
    ./task/doorkeep/: doorkeep_task.c
    ./task/status/: status_task.c
    ./task/uart/: uart_task.c
    ./task/adc/: adc_task.c
  group drive
    ./driver/flash/: flash_drv.c
    ./driver/timer/: timer_drv.c
    ./driver/uart/: uart_drv.c
